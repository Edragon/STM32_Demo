# Keil uVision project 32ctl.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 32_duoji +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\Libraries\src;..\Libraries\inc;..\Startup;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\TB_LIB\GPIO;..\TB_LIB\USART;..\TB_LIB\RCC;..\TB_LIB\GLOBAL;..\TB_LIB\DELAY;..\TB_LIB\TIMER;..\TB_LIB\PS2_SONY;..\TB_LIB\ADC;..\TB_LIB\w25q64
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: stm32f10x_it.c main.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group TB_LIB
    ../TB_LIB/GPIO/: tb_gpio.c
    ../TB_LIB/RCC/: tb_rcc.c
    ../TB_LIB/DELAY/: tb_delay.c
software components: CMSIS:CORE 5.1.2
